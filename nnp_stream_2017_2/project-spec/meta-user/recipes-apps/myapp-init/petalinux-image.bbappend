IMAGE_INSTALL_append = " myapp-init"
