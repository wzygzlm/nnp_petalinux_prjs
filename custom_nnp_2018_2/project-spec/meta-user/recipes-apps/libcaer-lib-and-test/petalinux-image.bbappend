IMAGE_INSTALL_append = " libcaer-lib-and-test"
