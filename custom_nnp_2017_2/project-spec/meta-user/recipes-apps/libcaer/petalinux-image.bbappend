IMAGE_INSTALL_append = " libcaer"
